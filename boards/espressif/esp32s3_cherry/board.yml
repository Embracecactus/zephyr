## boards/espressif/esp32s3_cherry/board.yml
```yaml
board:
  name: esp32s3_cherry
  full_name: ESP32-S3-CHERRY
  vendor: espressif
  socs:
  - name: esp32s3
```
